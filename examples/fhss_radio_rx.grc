<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fhss_radio_rx</value></param>
<param><key>title</key><value>FHSS Radio</value></param>
<param><key>author</key><value>John Malsbury</value></param>
<param><key>description</key><value>FHSS Transmitter - Top Level</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>S</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>link_speed</value></param>
<param><key>label</key><value>Link Speed(bps)</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate_0</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lead_limit</value></param>
<param><key>label</key><value>Lead Limit(s)</value></param>
<param><key>value</key><value>0.050</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>a</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hop_interval</value></param>
<param><key>label</key><value>Hop Interval(s)</value></param>
<param><key>value</key><value>0.050</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_guard</value></param>
<param><key>label</key><value>Post Guard(s)</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_guard</value></param>
<param><key>label</key><value>Pre Guard(s)</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_list</value></param>
<param><key>value</key><value>915e6,916e6,917e6</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>fhss_rx_hier</key>
<param><key>id</key><value>fhss_rx_hier_0</value></param>
<param><key>lead_limit</key><value>lead_limit</value></param>
<param><key>link_speed</key><value>samp_rate/samp_per_sym</value></param>
<param><key>freq</key><value>freq</value></param>
<param><key>rate</key><value>samp_rate</value></param>
<param><key>tx_gain</key><value>tx_gain</value></param>
<param><key>ampl</key><value>ampl</value></param>
<param><key>args</key><value>args</value></param>
<param><key>samp_per_sym</key><value>samp_per_sym</value></param>
<param><key>rx_gain</key><value>rx_gain</value></param>
<param><key>freq_list</key><value>freq_list</value></param>
<param><key>hop_interval</key><value>0.050</value></param>
<param><key>post_guard</key><value>0.002</value></param>
<param><key>pre_guard</key><value>0.002</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>extras_socket_msg</key>
<param><key>id</key><value>extras_socket_msg_0</value></param>
<param><key>proto</key><value>TCP</value></param>
<param><key>addr</key><value>127.0.0.1</value></param>
<param><key>port</key><value>port</value></param>
<param><key>mtu</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>port</value></param>
<param><key>label</key><value>p</value></param>
<param><key>value</key><value>12345</value></param>
<param><key>type</key><value>string</value></param>
</block>
<connection><source_block_id>fhss_rx_hier_0</source_block_id><sink_block_id>extras_socket_msg_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_socket_msg_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
