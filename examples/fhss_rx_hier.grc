<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>fhss_rx_hier</value></param>
<param><key>title</key><value>FHSS_RX Hier</value></param>
<param><key>author</key><value>John Malsbury</value></param>
<param><key>description</key><value>USRP FHSS Implementation</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MAC</value></param>
</block>
<block>
<key>digital_gmsk_demod</key>
<param><key>id</key><value>gmsk_demod</value></param>
<param><key>samples_per_symbol</key><value>samp_per_sym</value></param>
<param><key>gain_mu</key><value>0.175</value></param>
<param><key>mu</key><value>0.5</value></param>
<param><key>omega_relative_limit</key><value>0.005</value></param>
<param><key>freq_error</key><value>0.0</value></param>
</block>
<block>
<key>precog_packet_deframer</key>
<param><key>id</key><value>precog_packet_deframer_0</value></param>
<param><key>access_code</key><value></value></param>
<param><key>threshold</key><value>-1</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>usrp_source</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value>args</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>18</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value></value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pkt_out</value></param>
<param><key>label</key><value>pkt_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>lead_limit</value></param>
<param><key>label</key><value>Lead Limit(s)</value></param>
<param><key>value</key><value>0.050</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>link_speed</value></param>
<param><key>label</key><value>Link Speed(bps)</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq</value></param>
<param><key>value</key><value>915e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>rate</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rate</value></param>
<param><key>label</key><value>S</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ampl</value></param>
<param><key>label</key><value>a</value></param>
<param><key>value</key><value>0.7</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>args</value></param>
<param><key>label</key><value>args</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_per_sym</value></param>
<param><key>label</key><value>sps</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>rx_gain</value></param>
<param><key>value</key><value>15</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>hop_interval</value></param>
<param><key>label</key><value>Hop Interval(s)</value></param>
<param><key>value</key><value>0.050</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>post_guard</value></param>
<param><key>label</key><value>Post Guard(s)</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>pre_guard</value></param>
<param><key>label</key><value>Pre Guard(s)</value></param>
<param><key>value</key><value>0.002</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_list</value></param>
<param><key>value</key><value>915e6,916e6,917e6</value></param>
<param><key>type</key><value>string</value></param>
</block>
<block>
<key>fhss_engine_rx</key>
<param><key>id</key><value>fhss_engine_rx_0</value></param>
<param><key>hop_interval</key><value>hop_interval</value></param>
<param><key>post_tune_guard_interval</key><value>post_guard</value></param>
<param><key>pre_tune_guard_interval</key><value>pre_guard</value></param>
<param><key>rx_freq_list</key><value>freq_list</value></param>
<param><key>lead_limit</key><value>lead_limit</value></param>
<param><key>link_bps</key><value>samp_rate/samp_per_sym</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import precog</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>ctrl_out</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>label</key><value>ctrl_out</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>gr_tag_debug</key>
<param><key>id</key><value>gr_tag_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>name</key><value></value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>vlen</key><value>1</value></param>
<param><key>display</key><value>True</value></param>
</block>
<block>
<key>extras_pmt_rpc</key>
<param><key>id</key><value>extras_pmt_rpc_0</value></param>
<param><key>result_msg</key><value>False</value></param>
</block>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>gmsk_demod</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gmsk_demod</source_block_id><sink_block_id>precog_packet_deframer_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp_source</source_block_id><sink_block_id>fhss_engine_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>precog_packet_deframer_0</source_block_id><sink_block_id>fhss_engine_rx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fhss_engine_rx_0</source_block_id><sink_block_id>extras_pmt_rpc_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_engine_rx_0</source_block_id><sink_block_id>ctrl_out</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fhss_engine_rx_0</source_block_id><sink_block_id>pkt_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>extras_pmt_rpc_0</source_block_id><sink_block_id>gr_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>precog_packet_deframer_0</source_block_id><sink_block_id>gr_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
